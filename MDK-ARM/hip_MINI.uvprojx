# Keil uVision project hip_MINI.uvprojx, settings and files
target hip_MINI (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: hip_MINI +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,MBEDTLS_CONFIG_FILE=<mbedTLS_config.h>,MBEDTLS_PSK_MAX_LEN=48
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Middlewares/WIZnet/ioLibrary_Driver/Application;../Middlewares/WIZnet/ioLibrary_Driver/Ethernet;../Middlewares/WIZnet/ioLibrary_Driver/Ethernet/W5500;../Middlewares/WIZnet/ioLibrary_Driver/Internet/DHCP;../HART;..\MBEDTLS\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/User/HART
    ../HART/: hip_app.c hip_cmd.c hip_svr.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Middlewares/WIZnet_ioLibrary
    ../Middlewares/WIZnet/ioLibrary_Driver/Internet/DHCP/: dhcp.c
    ../Middlewares/WIZnet/ioLibrary_Driver/Ethernet/: socket.c wizchip_conf.c
    ../Middlewares/WIZnet/ioLibrary_Driver/Application/: tcp_server.c
    ../Middlewares/WIZnet/ioLibrary_Driver/Ethernet/W5500/: w5500.c
  group mbedTLS/Port
    ../MBEDTLS/Target/: hardware_rng.c
    ../MBEDTLS/App/: mbedtls.c net_sockets.c
software components: CMSIS:CORE 6.1.1, Security:mbed TLS 3.6.4
